options:
  parameters:
    generate_options: qt_gui
    id: simple_hackrf
    output_language: python
    title: Signal gen
  states: {}

blocks:
- name: carrier_frequency
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency (MHz)
    start: '1'
    step: '0.1'
    stop: '6000'
    value: '903'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tone_amplitude
  id: variable_qtgui_range
  parameters:
    label: Tone Amplitude
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0.75'
  states: {}
- name: tone_frequency
  id: variable_qtgui_range
  parameters:
    label: Tone Frequency (kHz)
    start: '-samp_rate/2/1e3'
    step: samp_rate/400/1e3
    stop: samp_rate/2/1e3
    value: '0'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: VGA Gain (dB)
    start: '0'
    step: '1'
    stop: '47'
    value: '16'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tone_amplitude
    freq: tone_frequency*1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\novaj\OneDrive\Documents\recordedSignal.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: C:\Users\novaj\Downloads\5MHz_PUSCH_PCI25_samplerate10MHz_16ms.iq.tar - works!
    file: C:\Users\novaj\Downloads\5MHz_PUSCH_PCI25_samplerate10MHz_16ms.iq.tar
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_frequency * 1e6
    fftsize: '1024'
    name: Transmitter
    type: complex
    ymin: '-63'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_frequency * 1e6
    fftsize: '1024'
    name: Reciever
    type: complex
    ymin: '-63'
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: 5e6
    center_freq: carrier_frequency * 1e6
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: carrier_frequency*1e6
    dev_args: hackrf=0
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', soapy_hackrf_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
